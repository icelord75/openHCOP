# Repository icelord75/openHCOP

File README.md:

# openHCOP

Coil-on-plug controller for HONDA H- F- D- B-series OBD1 Engines.

Piggyback ignition controller, for replace distributor internals: igniter unit, ignition coil, distributor cap and coil wires with Coil-on-plug.

Direct connection to CYL angle sensor - Orange(signal) and White(ground) wires (OBD1 distributers),
Solder directly to sensor wires, do not cut and/or twist over wires!

Support positive triggering 3-wire Coil-On-Plugs.

## Proof of work

## Order board

Order from [OSHPark](https://oshpark.com/shared_projects/Hhu0kevI)

## License

**openHCOP** is available under GPL License.

## EAGLE design schematics/Internal/openHCOP-internal.brd

Parts:
1, 2, 3, 4: LSP13
+12: SE14
+COILS: SE14
-COILS: SE14
C1: 22µ25v; SMC_C
C1<, C1>, C1_GND, C1_GND2: LSP11
C2: 22µ25v; SMC_E
C3: 10n; C0805
C4, C5: 100n; C0805
D1, D2, D3, D5, D6: 1N4148W; SOD-123FL
D9: 4.7V; SOD-123
H1, H2: MOUNT-PAD-ROUND5.0; 5,0-PAD
IC2: 78L05F; SOT89
IGN<: LSP13
J1: AVR_SPI_PROG_3X2PTH; 2X3
L1: 100uH; PIS2816
LED1: KP-1608MGC; CHIPLED_0603
Q1, Q2: MMBT2222; SOT23-BEC
R1: 4.7K; R0805
R2, R5: 10K; R0805
R3: 15K; R0805
R4: 180; R0805
R6: 1K; R0805
R7: 30K; R0805
TACH>: LSP13
U1: ATTINY44A-SSU; SOIC127P600X175-14N

Connections:
+12: +12.MP, +COILS.MP, C2.+, L1.1
+12F: C1.+, C5.1, IC2.3 (VI), L1.2, R5.2
COIL1: 1.MP, D2.C
COIL2: 2.MP, D5.C
COIL3: 3.MP, D3.C
COIL4: 4.MP, D6.C
CYP1: Q1.C, R2.1, U1.13 (PA0)
GND: -COILS.MP, C1.-, C1_GND.MP, C1_GND2.MP, C2.-, C3.2, C4.2, C5.2, D9.A, H1.B5, H2.B5, IC2.2 (GND), IC2.2@1 (GND), J1.6, Q1.E, Q2.E, R3.1, R4.2, U1.14 (GND)
IGN: D9.C, R7.1, U1.11 (PA2)
IGN1: D2.A, U1.2 (PB0)
IGN2: D5.A, U1.3 (PB1)
IGN3: D3.A, U1.5 (PB2)
IGN4: D6.A, U1.6 (PA7)
IGNITE: IGN<.MP, R7.2
LED: LED1.A, U1.10 (PA3)
MISO: J1.1, U1.8 (PA5)
MOSI: J1.4, U1.7 (PA6)
unnamed: D1.C, Q1.B
unnamed: LED1.C, R4.1
unnamed: Q2.B, R6.1
unnamed: C3.1, D1.A, R1.1, R3.2
PICKUP: C1<.MP, C1>.MP, R1.2
RST: J1.5, U1.4 (PB3)
SCK: J1.3, U1.9 (PA4)
TACH: Q2.C, R5.1, TACH>.MP
TACHO: R6.2, U1.12 (PA1)
VCC: C4.1, IC2.1 (VO), J1.2, R2.2, U1.1 (VCC)

Notes on the sheet:
Ab0VE-TECH OPEN HONDA COIL ON PLUG CONTROLLER https://github.com/icelord75/openHCOP

Board: 2 copper layers, 79.0 x 43.0 mm, 41 parts (0 on the bottom side), 27 nets.

Other parts of the board:
U$1: OSHW-LOGO-L

File schematics/Internal/openHCOP-BOM.txt (part):

Partlist exported from C:/Users/ice/ownCloud/Development/openHCOP/schematics/Internal/openHCOP-internal.sch at 02.12.2021 23:29

Part    Value               Device              Package             Description                                             MPN           OC_FARNELL OC_NEWARK PACKAGE POPULARITY PROD_ID   SPICEPREFIX SUPPLIER VALUE
+12     LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
+COILS  LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
-COILS  LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
1       LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
2       LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
3       LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
4       LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
C1      22µ25v              CPOL-EUSMCC         SMC_C               POLARIZED CAPACITOR, European symbol                                                                                                              
C1<     LSP11               LSP11               LSP11               SOLDER PAD                                                                                         5                                              
C1>     LSP11               LSP11               LSP11               SOLDER PAD                                                                                         5                                              
C1_GND  LSP11               LSP11               LSP11               SOLDER PAD                                                                                         5                                              
C1_GND2 LSP11               LSP11               LSP11               SOLDER PAD                                                                                         5                                              
C2      22µ25v              CPOL-EUSMCE         SMC_E               POLARIZED CAPACITOR, European symbol                                                                                                              
C3      10n                 C-EUC0805           C0805               CAPACITOR, European symbol                                                                                                                        
C4      100n                C-EUC0805           C0805               CAPACITOR, European symbol                                                                                                                        
C5      100n                C-EUC0805           C0805               CAPACITOR, European symbol                                                                                                                        
D1      1N4148W             DIODE_SOD-123FL     SOD-123FL           Diode                                                                                                                                             
D2      1N4148W             DIODE_SOD-123FL     SOD-123FL           Diode                                                                                                                                             
D3      1N4148W             DIODE_SOD-123FL     SOD-123FL           Diode                                                                                                                                             
D5      1N4148W             DIODE_SOD-123FL     SOD-123FL           Diode                                                                                                                                             
D6      1N4148W             DIODE_SOD-123FL     SOD-123FL           Diode                                                                                                                                             
D9      4.7V                DIODE-ZENER16V      SOD-123             Zener Diode                                                                                                   DIO-12440                      16V  
H1                          MOUNT-PAD-ROUND5.0  5,0-PAD             MOUNTING PAD, round                                                                                0                                              
H2                          MOUNT-PAD-ROUND5.0  5,0-PAD             MOUNTING PAD, round                                                                                0                                              
IC2     78L05F              78L05F              SOT89               POSITOIV-VOLTAGE REGULATORS                                                                                                                       
IGN<    LSP13               LSP13               LSP13               SOLDER PAD drill 1.3 mm, distributor Buerklin, 12H562                                              5                                              
J1      AVR_SPI_PROG_3X2PTH AVR_SPI_PROG_3X2PTH 2X3                 AVR ISP 6 Pin                                                                                                                                     
L1      100uH               L-USPIS2816         PIS2816             INDUCTOR, American symbol                                                                                               L                         
LED1    KP-1608MGC          LEDCHIPLED_0603     CHIPLED_0603        LED                                                                                                                                               
Q1      MMBT2222            BC849SMD            SOT23-BEC           NPN Transistor                                                                                                                                    
Q2      MMBT2222            BC849SMD            SOT23-BEC           NPN Transistor                                                                                                                                    
R1      4.7K                R-EU_R0805          R0805               RESISTOR, European symbol                                                                                                                         
R2      10K                 R-EU_R0805          R0805               RESISTOR, European symbol                                                                                                                         
R3      15K                 R-EU_R0805          R0805               RESISTOR, European symbol                                                                                                                         
R4      180                 R-EU_R0805          R0805               RESISTOR, European symbol                                                                                                                         
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
## EAGLE design openHCOP.old/schematics/V.5-production/openHCOP-micro.brd

Parts:
+12: TPPAD1-13Y; P1-13Y
C1: 22µ16v; SMC_B
C3: 10n; C0402
C4, C5: 100n; C0402
D1, D2, D3, D5, D6: 1N4148W; SOD882(T)
D9: 4.7V; SOD-123
GND: TPPAD1-13Y; P1-13Y
I1, I2, I3, I4: TPPAD1-13Y; P1-13Y
IC1: ATTINY20-UUR; BGA12C40P6X4_156X140X54
IC2: 78L05F; SOT89
IGN: TPPAD1-13Y; P1-13Y
J1: AVR_SPI_PROG_3X2PTH; 2X3
LED1: KP-1608MGC; CHIPLED_0603
P2, P3: TPPAD1-13Y; P1-13Y
R1: 4.7K; R0402
R2, R5, R7: 10K; R0402
R3: 15K; R0402
R4: 180; R0402
R6: 1K; R0402
T1, T2: BC847BT; SOT416
TACH: TPPAD1-13Y; P1-13Y

Connections:
+12: +12.TP, C1.+, C5.1, IC2.3 (VI), R5.2
GND: C1.-, C3.2, C4.2, C5.2, D9.A, GND.TP, IC1.B4 (GND), IC2.2 (GND), IC2.2@1 (GND), J1.6, P2.TP, R3.1, R4.2, T1.2 (E), T2.2 (E)
IGN: D9.C, R7.1
IGN1: D2.2 (A), IC1.D6 (PB0)
IGN2: D5.2 (A), IC1.C5 (PB1)
IGN3: D3.2 (A), IC1.D2 (PB2)
IGN4: D6.2 (A), IC1.C3 (PA7)
MISO: IC1.A5 (PA2), IC1.C1 (PA5), J1.1
MOSI: IC1.B2 (PA6), J1.4, LED1.A
unnamed: R6.1, T2.1 (B)
unnamed: IGN.TP, R7.2
unnamed: D1.1 (K), T1.1 (B)
unnamed: LED1.C, R4.1
unnamed: R5.1, T2.3 (C), TACH.TP
unnamed: D2.1 (K), I1.TP
unnamed: D5.1 (K), I2.TP
unnamed: D6.1 (K), I4.TP
unnamed: D3.1 (K), I3.TP
unnamed: C3.1, D1.2 (A), R1.1, R3.2
PICKUP: P3.TP, R1.2
RST: IC1.D4 (PB3), J1.5
SCK: IC1.A1 (PA4), J1.3, R2.1, T1.3 (C)
TACHO: IC1.A3 (PA1), R6.2
VCC: C4.1, IC1.B6 (VDD), IC2.1 (VO), J1.2, R2.2

Notes on the sheet:
Ab0VE-TECH OPEN HONDA COIL ON PLUG CONTROLLER https://github.com/icelord75/openHCOP

Board: 2 copper layers, 27.0 x 27.9 mm, 33 parts (0 on the bottom side), 24 nets.

## Code that names these connections

File src/main.c:

/*
   //      _______ __  _________ _________
   //      \_     |  |/  .  \   |   \ ___/
   //        / :  |   \  /   \  |   / _>_
   //       /      \ | \ |   /  |  /     \
   //      /   |___/___/____/ \___/_     /
   //      \___/--------TECH--------\___/
   //        ==== ABOVE SINCE 1994 ====
   //
   //   Ab0VE TECH - Open HONDA Coil on Plug Controller
   //             Inline4 - ATTINY24/44mod
 */

#include <avr/io.h>
#include <avr/wdt.h>
#include <avr/interrupt.h>
#include <util/delay.h>

// OUTPUT
#define IGNITION1 PINB0
#define IGNITION2 PINB1
#define IGNITION3 PINB2
#define IGNITION4 PINA7
#define LED PINA3
#define TACHO PINA1

// INPUT
#define CYP1 PINA0
#define IGN PINA2

// VARS
uint8_t CYLINDER = 0;
uint8_t SPARKS = 0;
uint16_t RPM = 0;
uint8_t LEDSTATUS = 0;

#define WATCHDOG_DELAY WDTO_30MS // Set watchdog for 30 mSec

void Led_ON()
{
        PORTA |= _BV(LED); // LED ON
}

void Led_OFF()
{
        PORTA &= ~_BV(LED); // LED OFF
}

// TIMER
ISR(TIM1_COMPA_vect)
{
        if (CYLINDER < 1)
        { // BLINK SLOW Before start engine.
                // Blink on timer
                if (LEDSTATUS == 0)
                { // Change LED on 2/10 sec
                        Led_OFF();
                        LEDSTATUS = 1;
                }
                else
                {
                        Led_ON();
                        LEDSTATUS = 0;
                }
        }
        RPM = SPARKS * 60 * 10 / 8;
        SPARKS = 0;
}

void Ignite_ON()
{
        switch (CYLINDER)
        { // Set fire for required coil 1-3-4-2
        case 0:
                break; // SKIP fire until first CYP signal
        case 1:
                PORTB |= _BV(IGNITION1);
                break;
        case 2:
                PORTB |= _BV(IGNITION3);
                break;
        case 3:
                PORTA |= _BV(IGNITION4);
                break;
        case 4:
                PORTB |= _BV(IGNITION2);
                break;
        }
}

void Ignite_Off() // disable ALL ignite ports for reason
{
        PORTB = 0;                // Off IGNITION1/2/3
        PORTA &= ~_BV(IGNITION4); // OFF IGNITION4
}

// PCINT0 Vector handling PINS: PCINT0 and PCINT2
ISR(PCINT0_vect)
{
        cli();
        // Check CYP1
        if ((PINA & _BV(CYP1)) == 0)
        { // CYP1 - LOW
                CYLINDER = 1;
                // change led on on CYP1
                if (LEDSTATUS == 0)
                {
                        Led_OFF();
                        LEDSTATUS = 1;
                }
                else
                {
                        Led_ON();
                        LEDSTATUS = 0;
                }
                /***/
        }

        PORTA |= _BV(TACHO); // ON TACH in any cases

        // Check IGN only after CYP1 triggered
        if (((PINA & _BV(IGN)) == 0) && (CYLINDER != 0))
        {
                // Start FIRE - LOW after first CYP1
                Ignite_ON();
                SPARKS++; // counter for RPM calc
                while ((PINA & _BV(IGN)) == 0)
                {
                        // Wait end of IGN signal
                }
                Ignite_Off();
                CYLINDER++;
                if (CYLINDER > 4)
                {
                        // if we lost CYP1 signal start from first any way
                        CYLINDER = 1;
                }
        }
        
        PORTA &= ~_BV(TACHO); // OFF TACH in any cases
        sei();
}

int main(void)
{
        cli();
        CYLINDER = 0; // Make shure for wait CYP1

        // Setup
        DDRB = _BV(IGNITION1) | _BV(IGNITION2) | _BV(IGNITION3);
        DDRA = _BV(TACHO) | _BV(LED) | _BV(IGNITION4);
        GIMSK = _BV(PCIE0);
        MCUCR |= _BV(ISC00); // ISC00 - any change
        PCMSK0 = _BV(PCINT0) | _BV(PCINT2);

        // Timer1 is used as 1/10 sec time base
        // Timer Clock = 1/1024 of sys clock
        // Mode = CTC (Clear Timer On Compare)
        TCCR1B |= ((1 << WGM12) | (1 << CS12) | (1 << CS10));
        OCR1A = 8000000 / 1024 / 10; // Compare value
        TIMSK1 |= (1 << OCIE1A);     // Output compare 1A interrupt enable

        // Enable WATCDOG
        wdt_enable(WATCHDOG_DELAY);

        // Start Triggers
        sei();

        // Main loop
        while (1)
        {
                wdt_reset(); // reset WDR
                _delay_us(1);
        }
}

## Commit log

2017-08-01 INITIAL
2017-08-01 real files
2017-08-01 update links
2017-08-01 New schematics
2017-08-01 Licensed
2017-08-01 License fix
2017-08-01 Create LICENSE
2017-08-02 add DirectFire option
2017-08-03 - first ignition fix - beautification
2017-08-08 syntax errors
2017-08-14 RESET PIN fix
2017-08-14 readme fix
2017-08-14 PCB routing update
2017-08-16 some fixes and updates
2017-08-24 readme updates
2017-08-24 readme update
2017-08-24 code formating
2017-08-27 optimization
2017-08-30 board routing fix
2017-08-31 rerouting and pins changed
2017-08-31 fuses and beauty
2017-09-01 a lot fixes and schematic update
2017-09-01 minor board updates
2017-09-03 process
2017-09-04 fixes
2017-09-05 bug fix
2017-09-05 global changes - not verified on hardware^ yet :(
2017-09-06 global changes, no extra features - only COP
2017-09-06 times vect rewrite
2017-09-07 Fixed for 12V negative pulse IGN signal
2017-09-07 components fix
2017-09-07 board fix
2017-09-07 will add it later
2017-09-07 little fixes
2017-09-12 beatification
2017-09-30 two kind of board
2017-10-17 minor
2017-11-18 schematics update
2017-11-25 schemes update
2017-12-02 illustrations
2017-12-02 updated for https://oshpark.com/ production
2017-12-21 mods
2018-01-15 Improved engine start and high revs with pickup input update
2018-01-16 Proof of work
2018-03-19 Release update
2018-03-19 BOM update
2018-03-19 production update
2018-03-19 Added OpenHardware logo
2018-03-19 Drilling fix
2018-03-29 Makefile added§
2018-03-29 Images update
2018-03-29 Documentation and clean
2018-05-02 minor updates
2019-04-16 another update
2019-04-16 vs code
2019-04-22 some
2021-12-02 Add internal board and schematics
2021-12-02 schematics
2021-12-02 clean
2024-08-30 tacho update for ODB-1 usage without stock igition cotroller

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
